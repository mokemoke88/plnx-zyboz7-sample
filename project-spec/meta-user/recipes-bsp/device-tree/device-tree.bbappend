FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
  file://system-user.dtsi \
  file://zyboz7-usb.dtsi \
  file://system-udmabuf.dtsi \
"
